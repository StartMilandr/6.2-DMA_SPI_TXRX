# Keil uVision project DMA_SPI_TXRX.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: MDR1986BE1T Milandr
  pack: Keil.MDR1986BExx.1.4
  cpu: IRAM(0x20000000,0x8000) IRAM2(0x20100000,0x4000) IROM(0x00000000,0x20000) CPUTYPE("Cortex-M1") CLOCK(12000000) ELITTLE
  output: DMA_SPI_TXRX
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\src_brd;..\6.2-DMA_SPI_TXRX
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  memory RVCT10: RAM 0x20100000 size 0x4000
  scatter file: .\Objects\DMA_SPI_TXRX.sct
  group user
    ./: main.c
    ./src_brd/: brdClock.c brdDMA.c brdLed.c brdSPI.c brdUtils.c
software components: Device:Startup_MDR1986BE1T 1.3.1, Drivers:DMA 1.3.1, Drivers:EEMPROM 1.3.1, Drivers:PORT 1.3.1, Drivers:RST_CLK 1.3.1, Drivers:SSP 1.3.1
